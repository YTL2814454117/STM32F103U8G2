# Keil uVision project dma-i2c-oled.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dma-i2c-oled +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Core;.\Lib\inc;.\Driver\inc;.\User;.\u8g2\csrc;.\u8g2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Core/: core_cm3.c startup_stm32f10x_md.s
  group LIB
    ./Lib/src/: misc.c stm32f10x_dma.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_i2c.c
  group DRIVER
    ./Driver/src/: oled.c uart.c
  group USER
    ./User/: ctrl.c main.c system_stm32f10x.c stm32f10x_it.c
  group U8G2
    ./u8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c
    ./u8g2/u8g2-master/csrc/: u8x8_u8toa.c
